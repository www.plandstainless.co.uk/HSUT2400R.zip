Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-02-08T16:13:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.1.367 - Exporter 22.0.1.367 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 08 16:13:40 2022 * Host: Dean-Dell-Precision-3551 * Database: C:\Users\DEANJO~1.PLA\AppData\Local\Temp\06f27ea2-338d-4548-8b83-68197ded6b1b\bc403183-2731-47ce-a5ec-bab27a0c0756\ifc * Database version: 5507 * Database creation date: Tue Feb 08 16:13:34 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 08 16:13:34 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 08 16:13:34 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcBuildingElementProxy: Family1:Standard, Family1:Standard:207239
In: Level 1
Type - Material: 153_153_153
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connector_1_Diameter: 41.5 mm
Type - Identity Data - Description: SURGEONS SCRUB UP TROUGH; Manufacturer: PLAND STAINLESS Ltd; Model: HSUT2400R; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Standard; URL: www.plandstainless.co.uk
Type - Model Properties - Area: 5.25355 m2; Author: DeanJohnson; Category: HEALTH CARE; Center of Gravity: X: -118.114 mm Y: 83.063 mm Z: 1185.331 mm; COBie AssetType: Fixed; COBie BarCode: 5060021231598; COBie CreatedBy: Dean Johnson; COBie Description: HTM64 Scrub up Trough; COBie DocumentationLiterature: www.plandstainless.co.uk; COBie DurationUnit: Years; COBie ExpectedLife: 30; COBie Features: Right Hand Waste; COBie Finish: Satin/polished; COBie Grade: 304 1.4301; COBie Manufacturer: Plandstainless Ltd; COBie Material: Stainless Steel; COBie Model: Trinidad; COBie ModelNumber: HSUT2400R; COBie Size: 2400 x 400mm; COBie WarrantyDescription: Manufacturer's Warranty; COBie WarrantyDurationUnit: Years; COBie WarrantyDurrationParts: 2; COBie WarrantyGuarantorParts: YES; Company: PLAND STAINLESS Ltd; Date Created: 08/02/2022 00:00:00; Density: 8000 kg/m3; Designer: DeanJohnson; Design Status: 3; Mass: 41.0495 kg; Material: Stainless Steel; Part Number: HSUT2400R; Requested Accuracy: Low; Stock Number: HSUT2400R; Volume: 0.00513118 m3
Type - Other - Category: Specialty Equipment; Family Name: Family1
Type - Pset_ManufacturerTypeInformation - Manufacturer: PLAND STAINLESS Ltd
Type - Pset_ProductRequirements - Category: HEALTH CARE
Material: 153_153_153, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 2.62284 m2; Volume: 0.0083218 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_207239
Description: Flow; FlowDirection: SINK
